Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: (Número do Projeto)
Time: 2018-03-11T22:50:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Mar 11 22:50:03 2018 * Host: LAPTOP-KU6KBO0J * Database: C:\Users\gilda\AppData\Local\Temp\{A6D42545-6B25-4663-85A6-A947FE66C2A8}\ifc * Database version: 5507 * Database creation date: Sun Mar 11 22:50:01 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Mar 11 22:50:01 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Mar 11 22:50:01 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, (Número do Projeto)
Phase: (Status do Projeto)

# IfcSite, Default
RefLatitude: -24, -59, -59, -999999; RefLongitude: -49, -59, -59, -999999; RefElevation: 2.70717e-16 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Name | LongName | Elevation (m)
PLANTA BAIXA TÉRREO | PLANTA BAIXA TÉRREO | 1.2
PLANTA BAIXA 2º PAVIMENTO | PLANTA BAIXA 2º PAVIMENTO | 4

# IfcBuildingElementProxy: espacador, espacador:espacador:851682
In: PLANTA BAIXA 2º PAVIMENTO
Pset_BuildingElementProxyCommon - Reference: espacador

# IfcBuildingElementProxy: espacador2, espacador2:espacador2:855447
In: PLANTA BAIXA TÉRREO
Pset_BuildingElementProxyCommon - Reference: espacador2
